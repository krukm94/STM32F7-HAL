# Keil uVision project f7_proj.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: f7_proj
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: .\lib\CMSIS;.\lib\CMSIS\Include;.\lib\STM32F7xx_HAL_Driver;.\lib\STM32F7xx_HAL_Driver\Inc;.\lib\STM32F7xx_HAL_Driver\Inc\Legacy;.\lib;.\source;.\lib\BSP\STM32746G-Discovery;.\lib\BSP\STM32756G_EVAL;.\lib\FatFs\src\option;.\lib\FatFs\src\drivers;.\lib\FatFs\src;.\lib\Fonts;.\lib\Components\ft5336;.\lib\Components\Common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group source
    ./source/: main.c hal.c led.c button.c uart.c itoa.c sd_card.c lcd.c stm32f7_lcd.c
    ./: sd_opis.txt
  group lib
    ./lib/CMSIS/: system_stm32f7xx.c startup_stm32f746xx.s
    ./lib/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c
    ./lib/: stm32f7xx_it.c
    ./lib/BSP/STM32746G-Discovery/: stm32746g_discovery_sd.c stm32746g_discovery_sdram.c
  group FatFs/Drivers
    ./lib/FatFs/src/drivers/: sd_diskio.c
  group FatFs/Core
    ./lib/FatFs/src/: diskio.c ff.c ff_gen_drv.c
